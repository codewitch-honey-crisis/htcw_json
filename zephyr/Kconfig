## zephyr/Kconfig
```kconfig
menu "htcw_json configuration"
  config HTCW_JSON
    bool "Enable HTCW_JSON"
    default n
endmenu
```
